## conf/local.conf
```bitbake
MACHINE = "qemuarm64"
TEMPLATECONF=../meta-poky/conf
DL_DIR ?= "/yocto-cache/downloads"
SSTATE_DIR ?= "/yocto-cache/sstate-cache"
```
